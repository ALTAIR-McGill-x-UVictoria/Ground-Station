options:
  parameters:
    generate_options: qt_gui
    id: lora
    output_language: python
    title: LoRa_Decoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: int(samp_rate)
    sf: '8'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433*10**6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
